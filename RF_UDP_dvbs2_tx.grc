options:
  parameters:
    category: Custom
    description: DVB-S2 Loopback Tx/Rx Simulation
    generate_options: qt_gui
    id: dvbs2_tx_rx
    output_language: python
    title: DVB-S2 Tx/Rx Simulation
  states: {}

blocks:
- name: Es
  id: variable
  parameters:
    value: '1'
  states: {}
- name: EsN0
  id: variable
  parameters:
    value: 10 ** (esn0_db / 10)
  states: {}
- name: N0
  id: variable
  parameters:
    value: Es / EsN0
  states: {}
- name: code_rate
  id: variable
  parameters:
    value: modcod.upper().replace("8PSK", "").replace("QPSK", "")
  states: {}
- name: constellation
  id: variable
  parameters:
    value: modcod.replace(code_rate, "")
  states: {}
- name: esn0_db
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Es/N0 (dB)
    start: '0'
    step: '0.1'
    stop: '20'
    value: snr
  states: {}
- name: n_rrc_taps
  id: variable
  parameters:
    value: int(2*rrc_delay*sps) + 1
  states: {}
- name: pilot_len
  id: variable
  parameters:
    value: int((360-1)/16)*36
  states: {}
- name: plframe_len
  id: variable
  parameters:
    value: '33282'
  states: {}
- name: plheader_len
  id: variable
  parameters:
    value: '90'
  states: {}
- name: qtgui_freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Frequency Offset (Hz)
    start: '-sym_rate/4'
    step: 1e3
    stop: sym_rate/4
    value: freq_offset
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sym_rate * sps
  states: {}
- name: agc_gain
  id: parameter
  parameters:
    label: AGC gain
    type: eng_float
    value: '1'
  states: {}
- name: agc_rate
  id: parameter
  parameters:
    label: AGC update rate
    type: eng_float
    value: '1e-5'
  states: {}
- name: agc_ref
  id: parameter
  parameters:
    label: AGC's reference value
    type: eng_float
    value: '1'
  states: {}
- name: att
  id: parameter
  parameters:
    label: transmit attenation
    short_id: j
    type: eng_float
    value: '10.0'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/shinji-y/data/udp.out
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/in.ts
    repeat: 'True'
    type: byte
  states: {}
- name: debug
  id: parameter
  parameters:
    label: debugging level
    short_id: d
    type: intx
    value: '0'
  states: {}
- name: dtv_dvb_bbheader_bb_0
  id: dtv_dvb_bbheader_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_4
    rolloff: RO_0_20
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bbscrambler_bb_0
  id: dtv_dvb_bbscrambler_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bch_bb_0
  id: dtv_dvb_bch_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_ldpc_bb_0
  id: dtv_dvb_ldpc_bb
  parameters:
    constellation: MOD_OTHER
    framesize2: FECFRAME_NORMAL
    rate3: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvbs2_interleaver_bb_0
  id: dtv_dvbs2_interleaver_bb
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate1: C1_4
  states: {}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    interpolation: INTERPOLATION_OFF
    rate1: C1_4
  states: {}
- name: dtv_dvbs2_physical_cc_0
  id: dtv_dvbs2_physical_cc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    goldcode: '0'
    pilots: PILOTS_ON
    rate1: C1_4
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import time

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='TS Rate Monitor',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.last = time.time()
              self.count = 0

          def work(self, input_items, output_items):
              data = input_items[0]
              output_items[0][:] = data

              self.count += len(data)
              now = time.time()

              if now - self.last >= 1.0:
                  dt = now - self.last
                  rate = self.count / dt
                  print(f"TS input rate: {rate:.0f} bytes/s  ({rate*8:.0f} bit/s)", flush=True)
                  self.count = 0
                  self.last = now

              return len(output_items[0])
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: FECFRAME size
    short_id: f
    type: str
    value: normal
  states: {}
- name: freq
  id: parameter
  parameters:
    label: transmit frequency
    short_id: z
    type: complex
    value: '438080000'
  states: {}
- name: freq_offset
  id: parameter
  parameters:
    label: simulated carrier frequency offset in Hz
    type: eng_float
    value: '1000'
  states: {}
- name: gold_code
  id: parameter
  parameters:
    label: Gold code
    type: intx
    value: '0'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '20.0'
    bandwidth: '2000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq
    samplerate: samp_rate
    type: fc32
    uri: usb:3.3.5
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi, sqrt
  states: {}
- name: in_file
  id: parameter
  parameters:
    label: path to input file containing an MPEG TS stream
    type: str
    value: /home/shinji-y/data/test.ts
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: int(sps / 2)
    taps: firdes.root_raised_cosine(sps, samp_rate, sym_rate, rolloff, n_rrc_taps)
    type: ccf
  states: {}
- name: modcod
  id: parameter
  parameters:
    label: MODCOD
    short_id: m
    type: str
    value: QPSK1/4
  states: {}
- name: pl_freq_est_period
  id: parameter
  parameters:
    label: PL synchronizer's frequency estimation period in frames
    type: intx
    value: '20'
  states: {}
- name: rolloff
  id: parameter
  parameters:
    label: rolloff factor
    short_id: r
    type: eng_float
    value: '0.2'
  states: {}
- name: rrc_delay
  id: parameter
  parameters:
    label: RRC filter delay in symbol periods
    type: intx
    value: '25'
  states: {}
- name: rrc_nfilts
  id: parameter
  parameters:
    label: number of branches on the polyphase RRC filter
    type: intx
    value: '128'
  states: {}
- name: snr
  id: parameter
  parameters:
    label: starting SNR in dB
    type: eng_float
    value: '10'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: oversampling ratio in samples per symbol
    short_id: o
    type: eng_float
    value: '4'
  states: {}
- name: sym_rate
  id: parameter
  parameters:
    label: symbol rate in bauds
    short_id: s
    type: intx
    value: '333000'
  states: {}
- name: sym_sync_damping
  id: parameter
  parameters:
    label: symbol synchronizer's damping factor
    type: eng_float
    value: '1.0'
  states: {}
- name: sym_sync_loop_bw
  id: parameter
  parameters:
    label: symbol synchronizer's loop bandwidth
    type: eng_float
    value: '0.0045'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0
    label0: Simulation
    label1: Frequency Correction
    label2: Symbol Sync
    label3: Frame Recovery
    label4: Phase Recovery
    num_tabs: '5'
  states: {}

connections:
- [blocks_file_source_0, '0', epy_block_0, '0']
- [dtv_dvb_bbheader_bb_0, '0', dtv_dvb_bbscrambler_bb_0, '0']
- [dtv_dvb_bbscrambler_bb_0, '0', dtv_dvb_bch_bb_0, '0']
- [dtv_dvb_bch_bb_0, '0', dtv_dvb_ldpc_bb_0, '0']
- [dtv_dvb_ldpc_bb_0, '0', dtv_dvbs2_interleaver_bb_0, '0']
- [dtv_dvbs2_interleaver_bb_0, '0', dtv_dvbs2_modulator_bc_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', dtv_dvbs2_physical_cc_0, '0']
- [dtv_dvbs2_physical_cc_0, '0', interp_fir_filter_xxx_0, '0']
- [epy_block_0, '0', blocks_file_sink_0, '0']
- [epy_block_0, '0', dtv_dvb_bbheader_bb_0, '0']
- [interp_fir_filter_xxx_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
